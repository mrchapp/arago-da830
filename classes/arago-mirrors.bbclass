MIRRORS_append () {
ftp://.*/.*	http://arago-project.org/files/sources/
https?$://.*/.*	http://arago-project.org/files/sources/
}
