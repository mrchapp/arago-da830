require ti-dmai.inc

PV = "2_05_00_14"
PR = "r1"

COMPATIBLE_MACHINE = "(omap3evm|dm3730-am3715-evm)"

SRCREV         = "488"
DMAIBRANCH     = "tags/TAG_2_05_00_14"
