require ti-ipc.inc

PV = "1_00_05_60"

SRC_URI[md5sum] = "2dc790eda42790c47859fe7ee5d15391"
SRC_URI[sha256sum] = "22366ce6f071438124605b1fe01ee69bfc5cb1738a82eb6772cb792b207d8e0a"

