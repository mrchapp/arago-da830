require ti-sysbios.inc

PV = "6_21_00_13"

SRC_URI[sysbiosbin.md5sum] = "2cf2201b69375ce608caee52c600323f"
SRC_URI[sysbiosbin.sha256sum] = "0b74c7a6a40086de4728250aa249454238f38e41f2e90365a1bca8c128b6e97a"

