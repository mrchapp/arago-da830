require ti-cgt6x.inc

PE = "1"
PV = "6_1_14"
PVwithdots = "6.1.14"

SRC_URI[cgt6xbin.md5sum] = "494a980c2e1eb60480fff02e9b5877df"
SRC_URI[cgt6xbin.sha256sum] = "cc339770350767013d80a16cedcfea244ae668d5bbefbe1402e0d55104dd6389"

