require u-boot-omapl1.inc

# Use literal tags in SRCREV, when available, instead of commit IDs
SRCREV = "v2009.11_DAVINCIPSP_03.20.00.12"

UVER = "2009.11"
PSPREL = "03.20.00.12"

PR = "r1"
