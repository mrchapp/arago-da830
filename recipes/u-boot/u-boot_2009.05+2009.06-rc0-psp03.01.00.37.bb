require u-boot-davinci.inc

# Use literal tags in SRCREV, when available, instead of commit IDs
SRCREV = "DEV.DaVinciPSP.03.XX.00.37"

UVER = "2009.06-rc0"
PSPREL = "03.01.00.37"

PR = "r1"
