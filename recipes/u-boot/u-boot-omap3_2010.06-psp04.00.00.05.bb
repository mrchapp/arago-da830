require u-boot-omap3.inc

COMPATIBLE_MACHINE = "ti816x"

# Use literal tags in SRCREV, when available, instead of commit IDs
SRCREV = "308bfa87a88b1d1e2835e6712b4a89447f601f70"

PR = "r1"
