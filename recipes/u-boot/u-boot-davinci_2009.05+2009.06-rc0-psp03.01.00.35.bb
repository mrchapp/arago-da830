require u-boot-davinci.inc

# Use literal tags in SRCREV, when available, instead of commit IDs
SRCREV = "DEV.DaVinciPSP.03.XX.00.35"

PR = "r0"
