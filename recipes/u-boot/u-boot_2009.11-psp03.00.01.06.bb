require u-boot-omap3.inc

# Use literal tags in SRCREV, when available, instead of commit IDs
SRCREV = "c0a8fb217fdca7888d89f9a3dee74a4cec86562"

UVER = "2009.11"
PSPREL = "03.00.01.06"

PR = "r2"
