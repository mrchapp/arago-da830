require u-boot-davinci.inc

# Use literal tags in SRCREV, when available, instead of commit IDs
SRCREV = "DEV.DaVinciPSP.03.XX.00.35"

UVER = "2009.06-rc0"
PSPREL = "03.01.00.35"

PR = "r1"
