require linux-omap3.inc

COMPATIBLE_MACHINE = "ti816x"

KVER = "2.6.34"
PSPREL = "04.00.00.06"

# Use literal tags in SRCREV, when available, instead of commit IDs
SRCREV = "661585a1407961c5e71f1d8203f1a32f08e9a772"
