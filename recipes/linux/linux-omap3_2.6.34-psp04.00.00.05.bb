require linux-omap3.inc

COMPATIBLE_MACHINE = "ti816x"

KVER = "2.6.34"
PSPREL = "04.00.00.05"

# Use literal tags in SRCREV, when available, instead of commit IDs
SRCREV = "046197da00e36d7c7c25c0fb7768ec24db07a82b"
