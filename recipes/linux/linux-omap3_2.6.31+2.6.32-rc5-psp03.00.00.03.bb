require linux-omap3-psp2.inc

KVER = "2.6.31+2.6.32-rc5"
PSPREL = "03.00.00.03"

# Use this commit ID for a fix made after v2.6.32-rc5_OMAPPSP_03.00.00.03
SRCREV = "a73318ee3672f46c3d463d9a5f2c75f028a406f3"
