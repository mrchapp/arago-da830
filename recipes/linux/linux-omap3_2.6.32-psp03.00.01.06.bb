require linux-omap3_psp2.inc

COMPATIBLE_MACHINE = "(omap3evm|dm37x-evm|am37x-evm)"

KVER = "2.6.32"
PSPREL = "03.00.01.06"

SRCREV = "v2.6.32_OMAPPSP_03.00.01.06.patch1"
