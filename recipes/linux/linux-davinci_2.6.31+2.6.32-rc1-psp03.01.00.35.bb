require linux-davinci.inc

SRCREV = "DEV.DaVinciPSP.03.XX.00.35"

KVER = "2.6.32-rc1"
PSPREL = "03.01.00.35"
