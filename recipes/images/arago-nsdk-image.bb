
require arago-nsdk-image.inc

export IMAGE_BASENAME = "arago-nsdk-image"
